options:
  parameters:
    author: jesse_blair__diego_cardenas_j1B_G5
    generate_options: qt_gui
    id: lab1_punto2
    output_language: python
    title: lab1_punto2_muestreo
  states: {}

blocks:
- name: BW
  id: variable_qtgui_range
  parameters:
    label: ancho de banda
    start: '10'
    step: '10'
    stop: '50000'
    value: '1500'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: f_corte
  id: variable_qtgui_range
  parameters:
    label: frecuencia_corte
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frequency_central
    start: '100'
    step: '10'
    stop: '21000'
    value: '1500'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: frequencia de muestreo
    start: '1000'
    step: '1000'
    stop: '300000'
    value: '200000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: fc+BW/2
    low_cutoff_freq: fc-BW/2
    samp_rate: '200000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/algomegustadeti_WY.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: f_corte
    decim: '1'
    gain: '1'
    samp_rate: '200000'
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: f_corte
    gain: '1'
    interp: '1'
    samp_rate: '200000'
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: '200000'
    color2: '"green"'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    nconnections: '2'
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}
- name: rational_resampler_xxx_2_0
  id: rational_resampler_xxx
  parameters:
    decim: '200000'
    interp: '48000'
    type: fff
  states: {}

connections:
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [band_pass_filter_0, '0', rational_resampler_xxx_2_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_2, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [high_pass_filter_0, '0', rational_resampler_xxx_2_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0, '0', rational_resampler_xxx_2_0, '0']
- [rational_resampler_xxx_2, '0', band_pass_filter_0, '0']
- [rational_resampler_xxx_2, '0', high_pass_filter_0, '0']
- [rational_resampler_xxx_2, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_2, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_2_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
