options:
  parameters:
    generate_options: qt_gui
    id: modulador_de_a
    output_language: python
    title: modulador_de_a
  states: {}

blocks:
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud_portador(Ac)
    start: '0'
    step: '1e-3'
    stop: '1'
    value: '125e-3'
  states: {}
- name: Am
  id: variable_qtgui_range
  parameters:
    label: Amplitud del mensaje
    start: '0'
    step: '100e-3'
    stop: '4'
    value: '1'
  states: {}
- name: B
  id: variable_qtgui_range
  parameters:
    label: Cambio de banda
    start: '-1'
    step: '2'
    stop: '1'
    value: '1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: Ganancia transmisor
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia de portadora
    start: 50e6
    step: 1e6
    stop: 2.2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: frecuencia del mensaje
    start: '300'
    step: '100'
    stop: samp_rate/4
    value: 1e3
  states: {}
- name: k
  id: variable_qtgui_range
  parameters:
    label: habilita portadora
    start: '0'
    step: '1'
    stop: '1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12500000/8
  states: {}
- name: Practica3_2_0
  id: Practica3_2
  parameters:
    l_vect: '1024'
  states: {}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/labcom/Descargas/edacecar_bbc_dopamina.wav
    repeat: 'True'
  states: {}
- name: envolvente_compleja_0
  id: envolvente_compleja
  parameters:
    Ac: Ac
    cambio_de_banda: B
    habilita_portadora: k
    k: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48000'
    interp: '200000'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_0, '0']
- [envolvente_compleja_0, '0', qtgui_freq_sink_x_0, '0']
- [envolvente_compleja_0, '0', qtgui_time_sink_x_0, '0']
- [envolvente_compleja_0, '0', uhd_usrp_sink_0, '0']
- [rational_resampler_xxx_0, '0', Practica3_2_0, '0']
- [rational_resampler_xxx_0, '0', envolvente_compleja_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
